
CMDLINE_SERIAL = "console=serial0,115200 console=tty1"

CMDLINE += " loglevel=4"


